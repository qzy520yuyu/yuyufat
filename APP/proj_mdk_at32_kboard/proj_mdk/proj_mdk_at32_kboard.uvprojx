# Keil uVision project proj_mdk_at32_kboard.uvprojx, settings and files
target proj_mdk_at32_kboard (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: -AT32F425R8T7-7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.1.3
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: proj_mdk_at32_kboard +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin --output .\Objects\A01-3_V100.bin .\Objects\proj_mdk_at32_kboard.axf
  AfterMake: .\add.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F425R8T7,USE_STDPERIPH_DRIVER,AT_START_F425_V1
  c include: ..\..\AT32F425_Firmware_Library_V2.1.2\libraries\drivers\inc;..\..\AT32F425_Firmware_Library_V2.1.2\libraries\cmsis\cm4\core_support;..\..\AT32F425_Firmware_Library_V2.1.2\libraries\cmsis\cm4\device_support;..\source\main;..\source\protocol;..\source\bsp;..\source\bsp\bsp_gpio_key;..\source\bsp\bsp_gpio_led;..\source\bsp\bsp_hal_driver;..\source\bsp\bsp_iap;..\source\bsp\bsp_mcu_adc;..\source\bsp\bsp_mcu_core;..\source\bsp\bsp_pixel_led;..\source\local\kboard;..\source\bsp\bsp_usart;..\source\local\data_transer_local;..\source\bsp\bsp_mcu_adc;..\source\bsp\bsp_pixel_led;..\source\bsp;..\source\local\data_transer_local;..\source\crc;..\source\bsp\bsp_flash;..\source\bsp\bsp_mcu_tim;..\source\bsp\bsp_mcu_iap;..\source\local\protocol_handler;..\source\local\firmware;..\source\local\ota_handler;..\source\local\led_handler;..\source\local\key_handler
  memory RVCT4: ROM 0x8001000 size 0x7400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group thirdparty/at32_core
    ../../AT32F425_Firmware_Library_V2.1.2/libraries/cmsis/cm4/device_support/: system_at32f425.c
    ../../AT32F425_Firmware_Library_V2.1.2/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f425.s
  group thirdparty/at32_haldriver
    ../../AT32F425_Firmware_Library_V2.1.2/libraries/drivers/src/: at32f425_crm.c at32f425_gpio.c at32f425_usart.c at32f425_misc.c at32f425_dma.c at32f425_adc.c at32f425_acc.c at32f425_can.c at32f425_crc.c at32f425_debug.c at32f425_ertc.c at32f425_exint.c at32f425_flash.c at32f425_i2c.c at32f425_pwc.c at32f425_scfg.c at32f425_spi.c at32f425_tmr.c at32f425_usb.c at32f425_wdt.c at32f425_wwdt.c
  group interrupt
    ../source/main/: at32f425_int.c
  group board
    ../source/bsp/: board.c
    ../source/main/: at32f425_clock.c
    ../source/bsp/bsp_gpio_key/: bsp_gpio_key.c
    ../source/bsp/bsp_mcu_adc/: bsp_mcu_adc.c
    ../source/bsp/bsp_usart/: bsp_usart3_dma_txrx.c
    ../source/bsp/bsp_pixel_led/: bsp_pixel_led.c
    ../source/bsp/bsp_flash/: bsp_mcu_flash.c
    ../source/bsp/bsp_mcu_iap/: bsp_mcu_iap.c
    ../source/bsp/bsp_mcu_tim/: bsp_mcu_tim.c
  group software
    ../source/protocol/: protocol_tlvc.c protocol_tlvc.h
    ../source/crc/: crc.c
  group service
    ../source/local/firmware/: firmware.c
    ../source/local/led_handler/: led_handler.c
    ../source/local/ota_handler/: ota_handler.c
    ../source/local/protocol_handler/: protocol_handler.c
    ../source/local/key_handler/: key_handler.c
  group local
    ../source/local/kboard/: kboard.c
    ../source/local/data_transer_local/: data_transer_local.c
  group main
    ../source/main/: main.c
