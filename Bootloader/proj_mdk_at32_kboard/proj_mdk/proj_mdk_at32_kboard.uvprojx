# Keil uVision project proj_mdk_at32_kboard.uvprojx, settings and files
target proj_mdk_at32_kboard (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: -AT32F425R8T7-7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.1.3
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: proj_mdk_at32_kboard +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin --output .\Objects\A01-3_V100.bin .\Objects\proj_mdk_at32_kboard.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F425R8T7,USE_STDPERIPH_DRIVER,AT_START_F425_V1
  c include: ..\..\AT32F425_Firmware_Library_V2.1.2\libraries\drivers\inc;..\..\AT32F425_Firmware_Library_V2.1.2\libraries\cmsis\cm4\core_support;..\..\AT32F425_Firmware_Library_V2.1.2\libraries\cmsis\cm4\device_support;..\source\main;..\source\protocol_v1;..\source\bsp;..\source\bsp\bsp_flash;..\source\bsp\bsp_gpio_key;..\source\bsp\bsp_gpio_led;..\source\bsp\bsp_hal_driver;..\source\bsp\bsp_iap;..\source\bsp\bsp_mcu_adc;..\source\bsp\bsp_mcu_core;..\source\bsp\bsp_pixel_led;..\source\local\kboard;..\source\bsp\bsp_usart;..\source\local\data_transer_local;..\source\bsp\bsp_mcu_adc;..\source\bsp\bsp_pixel_led;..\source\bsp;..\source\local\data_transer_local
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group thirdparty/at32_core
    ../../AT32F425_Firmware_Library_V2.1.2/libraries/cmsis/cm4/device_support/: system_at32f425.c
    ../../AT32F425_Firmware_Library_V2.1.2/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f425.s
  group thirdparty/at32_haldriver
    ../../AT32F425_Firmware_Library_V2.1.2/libraries/drivers/src/: at32f425_crm.c at32f425_gpio.c at32f425_usart.c at32f425_misc.c at32f425_dma.c at32f425_adc.c at32f425_acc.c at32f425_can.c at32f425_debug.c at32f425_ertc.c at32f425_exint.c at32f425_flash.c at32f425_pwc.c at32f425_scfg.c at32f425_tmr.c at32f425_wdt.c at32f425_wwdt.c
  group interrupt
    ../source/main/: at32f425_int.c
  group board
    ../source/bsp/bsp_flash/: bsp_flash.c
    ../source/bsp/bsp_iap/: bsp_iap.c
  group main
    ../source/main/: main.c
